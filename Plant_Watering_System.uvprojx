# Keil uVision project Plant_Watering_System.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MKL05Z8xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFF00,0x00000400) IROM(0x00000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Plant_Watering_System
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x1fffff00 size 0x400
  group Source Group 1
    ./: ADC.h main.c ADC.c frdm_bsp.h i2c.c i2c.h klaw.c klaw.h lcd1602.c lcd1602.h leds.c leds.h lptmr.c lptmr.h pit.c pit.h TPM.c TPM.h tsi.c tsi.h
